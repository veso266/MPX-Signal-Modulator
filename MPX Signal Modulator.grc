<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>author</key><value>Mitja Kocjancic</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>MPX Signal Modulator</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dac_rate</value></param>
<param><key>value</key><value>128e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_max_dev</value></param>
<param><key>value</key><value>80e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fm_rate</value></param>
<param><key>value</key><value>192e3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>76e6</value></param>
<param><key>grid_pos</key><value>1, 1, 1, 1</value></param>
<param><key>label</key><value>Transmit Frequency</value></param>
<param><key>max</key><value>108e6</value></param>
<param><key>min</key><value>76e6</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>25</value></param>
<param><key>grid_pos</key><value>4, 1, 1, 1</value></param>
<param><key>label</key><value>IF Gain</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_dev</value></param>
<param><key>value</key><value>192e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>outbuffer</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>quad_rate</value></param>
<param><key>value</key><value>75e3</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>10</value></param>
<param><key>grid_pos</key><value>3, 1, 1, 1</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>300</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>192000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>2*math.pi*max_dev/quad_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_interp</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>usrp_rate</value></param>
<param><key>value</key><value>int(dac_rate/usrp_interp)</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_1</value></param>
<param><key>device_name</key><value>FM-LR</value></param>
<param><key>maxoutbuf</key><value>192000</value></param>
<param><key>minoutbuf</key><value>380</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>gr_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_frequency_modulator_fc</key>
<param><key>id</key><value>gr_frequency_modulator_fc_0</value></param>
<param><key>maxoutbuf</key><value>outbuffer</value></param>
<param><key>sensitivity</key><value>2*math.pi*fm_max_dev/usrp_rate</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>1e6</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1_1</value></param>
<param><key>decim</key><value>384</value></param>
<param><key>interp</key><value>2000</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>audio_source_1</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_1</source_block_id><sink_block_id>gr_add_xx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_add_xx_0</source_block_id><sink_block_id>gr_frequency_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_frequency_modulator_fc_0</source_block_id><sink_block_id>rational_resampler_xxx_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1_1</source_block_id><sink_block_id>osmosdr_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
